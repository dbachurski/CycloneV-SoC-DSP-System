require recipes-core/images/core-image-base.bb
require recipes-core/images/include/agh-image.inc

export IMAGE_BASENAME = "agh-image-base"
